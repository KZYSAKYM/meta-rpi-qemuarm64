# Enable 3d accel options and so on
PACKAGECONFIG_append = " virglrenderer kvm glx alsa gtk+ virtfs"
